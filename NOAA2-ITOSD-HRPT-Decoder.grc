options:
  parameters:
    author: Robin OK9UWU
    copyright: None
    description: ' '
    generate_options: qt_gui
    id: ITOSDDec
    output_language: python
    title: Decoder for NOAA-2 (ITOS-D) HRPT satellite signal.
  states: {}

blocks:
- name: fm_deviation_hz_IQ
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: fm_deviation_hz_subcar
  id: variable
  parameters:
    value: '29000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: samp_rate_decimated
  id: variable
  parameters:
    value: samp_rate/3
  states: {}
- name: subcarrier_frequency
  id: variable
  parameters:
    value: 99e3
  states: {}
- name: updaterate
  id: variable
  parameters:
    value: video_rate/videocolumns/1000
  states: {}
- name: video_rate
  id: variable
  parameters:
    value: '24994'
  states: {}
- name: videocolumns
  id: variable
  parameters:
    value: '5460'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate_decimated/(2*math.pi*fm_deviation_hz_IQ)
  states: {}
- name: analog_quadrature_demod_cf_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate_decimated/(2*math.pi*fm_deviation_hz_subcar)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path_to_your_baseband_in_f32_format
    repeat: 'False'
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier_frequency
    decim: '1'
    samp_rate: samp_rate_decimated
    taps: '150'
    type: ccc
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate_decimated
    type: fir_filter_ccf
    width: '20'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_decimated
    fc: 1697.5e6
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    alpha1: '2.0'
    color1: '2'
    gui_hint: 6,5,5,5
    label1: NOAA2 HRPT Raster
    name: Video Image
    ncols: videocolumns
    nrows: '900'
    samp_rate: video_rate
    type: float
    update_time: updaterate
    zmax: '7'
    zmin: '-7'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    grid: 'True'
    gui_hint: 1,5,5,5
    legend: 'False'
    name: Video Time-Domain
    size: videocolumns
    srate: video_rate
    type: float
    update_time: updaterate
    ymax: '10'
    ymin: '-9'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1500000'
    interp: '500000'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50000'
    interp: video_rate
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', hilbert_fc_0, '0']
- [analog_quadrature_demod_cf_2, '0', rational_resampler_xxx_1, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_2_0, '0']
- [hilbert_fc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [low_pass_filter_2_0, '0', analog_quadrature_demod_cf_2, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_raster_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
